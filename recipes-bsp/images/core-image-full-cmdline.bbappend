IMAGE_INSTALL:append = " \
        swupdate \
"
